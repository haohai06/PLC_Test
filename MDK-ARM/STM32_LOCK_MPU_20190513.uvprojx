# Keil uVision project STM32_LOCK_MPU_20190513.uvprojx, settings and files
target STM32_LOCK_MPU (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F070F6Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32_LOCK_MPU_20190513 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F070x6
  c misc: --c99
  c include: ../Inc;..\include;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\components\osal\include;..\components\osal\mcu\STM32F030C8;..\application\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Application/MDK-ARM
    ./: startup_stm32f070x6.s
  group Application/User
    ../Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c system_stm32f0xx.c
    ../Inc/: main.h
    ../application/: doorbell.c drv_rtc.c hal_uart.c hardware.c io_event.c lock_app_uart.c lock_config.c lock_motor.c OSAL_Task.c slave_lock_task.c
    ../include/: doorbell.h drv_rtc.h hal_uart.h hardware.h io_event.h lock_app_uart.h lock_config.h lock_motor.h OSAL_Task.h slave_lock_task.h
  group Application/mpu
    ../application/eMPL/: driver_icm20689.c driver_icm20689.h icm20689_V1.2.lib
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c
  group OSAL/COMMON
    ../components/osal/common/: OSAL_Timers.c OSAL_PwrMgr.c OSAL_Memory.c OSAL_Clock.c OSAL.c
  group OSAL/MCU
    ../components/osal/mcu/STM32F030C8/: hal_board.c
software components: CMSIS:CORE 5.1.1
